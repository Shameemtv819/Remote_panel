# Keil uVision project WOLF_MQTT.uvprojx, settings and files
target WOLF_MQTT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F207ZGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: WOLF_MQTT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c include: ../Core/Inc;../LWIP/App;../LWIP/Target;../wolfMQTT;../wolfSSL;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include;../Middlewares/Third_Party/wolfSSL_wolfMQTT_wolfMQTT/wolfmqtt/;../Middlewares/Third_Party/wolfSSL_wolfSSL_wolfSSL/wolfssl/;../scorpio_app;../scorpio_bsp;../Middlewares/Third_Party/wolfSSL_wolfMQTT_wolfMQTT/wolfmqtt/wolfmqtt
  asm include: ../Core/Inc;../LWIP/App;../LWIP/Target;../wolfMQTT;../wolfSSL;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include;../Middlewares/Third_Party/wolfSSL_wolfMQTT_wolfMQTT/wolfmqtt/;../Middlewares/Third_Party/wolfSSL_wolfSSL_wolfSSL/wolfssl/
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f2xx_it.c stm32f2xx_hal_msp.c stm32f2xx_hal_timebase_tim.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_crc.c stm32f2xx_hal_rng.c stm32f2xx_hal_uart.c
    ../../../Documents/Work_space/WOLF_MQTT/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_rtc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group MQTT_APP
    ../scorpio_app/: ca_cert.c flash.c html_page.c http_server_app.c https_client_app.c json_handler.c lte_app.c mcu_comm_app.c network_time.c scorpio_app.c task.c mqtt.c
  group MQTT_BSP
    ../scorpio_bsp/: bsp_lte.c bsp_relay.c common.c crc.c debug_uart.c mcu_comm_uart.c scorpio_bsp.c
  group code start fix
    ./: stdout_user.c
  group Middlewares/wolfMQTT/wolfMQTT/wolfMQTT/Core
    ../Middlewares/Third_Party/wolfSSL_wolfMQTT_wolfMQTT/wolfmqtt/src/: mqtt_client.c mqtt_packet.c mqtt_socket.c
  group Middlewares/wolfSSL/wolfSSL/wolfSSL/Core
    ../Middlewares/Third_Party/wolfSSL_wolfSSL_wolfSSL/wolfssl/src/: bio.c conf.c crl.c dtls.c dtls13.c internal.c keys.c ocsp.c pk.c quic.c sniffer.c ssl.c ssl_asn1.c ssl_bn.c ssl_certman.c ssl_crypto.c ssl_load.c ssl_misc.c ssl_p7p12.c ssl_sess.c tls.c tls13.c wolfio.c x509.c x509_str.c
  group Middlewares/wolfSSL/wolfSSL/wolfCrypt/Core
    ../Middlewares/Third_Party/wolfSSL_wolfSSL_wolfSSL/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c blake2s.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cryptocb.c cpuid.c curve448.c curve25519.c des3.c dh.c dsa.c ecc_fp.c ecc.c eccsi.c ed448.c ed25519.c error.c evp.c ext_kyber.c fe_448.c fe_low_mem.c fe_operations.c ge_448.c ge_low_mem.c ge_operations.c hash.c hmac.c hpke.c integer.c kdf.c logging.c md2.c md4.c md5.c misc.c memory.c pkcs7.c pkcs12.c poly1305.c pwdbased.c random.c rc2.c ripemd.c rsa.c sakke.c sha.c sha256.c sha3.c sha512.c signature.c sp_arm32.c sp_arm64.c sp_armthumb.c sp_c32.c sp_c64.c sp_cortexm.c sp_dsp32.c sp_int.c sp_x86_64.c srp.c tfm.c wc_dsp.c wc_encrypt.c wc_kyber.c wc_kyber_poly.c wc_lms.c wc_lms_impl.c wc_pkcs11.c wc_port.c wc_xmss.c wc_xmss_impl.c wolfevent.c wolfmath.c
    ../Middlewares/Third_Party/wolfSSL_wolfSSL_wolfSSL/wolfssl/wolfcrypt/src/port/arm/: armv8-32-curve25519_c.c armv8-32-sha512-asm_c.c armv8-aes.c armv8-chacha.c armv8-curve25519_c.c armv8-poly1305.c armv8-sha256.c armv8-sha512.c thumb2-aes-asm_c.c thumb2-chacha-asm_c.c thumb2-chacha.c thumb2-curve25519_c.c thumb2-kyber-asm_c.c thumb2-poly1305-asm_c.c thumb2-poly1305.c thumb2-sha256-asm_c.c thumb2-sha3-asm_c.c thumb2-sha512-asm_c.c
    ../Middlewares/Third_Party/wolfSSL_wolfSSL_wolfSSL/wolfssl/wolfcrypt/src/port/atmel/: atmel.c
    ../Middlewares/Third_Party/wolfSSL_wolfSSL_wolfSSL/wolfssl/wolfcrypt/src/port/st/: stm32.c stsafe.c
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
